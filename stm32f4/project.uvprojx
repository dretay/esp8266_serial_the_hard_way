# Keil uVision project project.uvprojx, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Flash OPT
    ./: STM32F40xxx_41xxx_OPT.s
  group Source Files
    ./: Thread_LED.c gfxconf.h board_PCD8544.h Startup.c Thread_ExtIO.c Thread_ESP8266_SPI.c Thread_ESP8266_UART.c
  group Documentation
    ./: Abstract.txt
  group ugfx
    ../../../Keil/libraries/ugfx_24_151114/src/: gfx_mk.c
    ../../../Keil/libraries/ugfx_24_151114/drivers/gdisp/PCD8544/: gdisp_lld_PCD8544.c
target STM32F407 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  c include: ..\..\..\Keil\libraries\ugfx_24_151114;..\..\..\Keil\libraries\ugfx_24_151114\drivers\gdisp\PCD8544;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:I2C 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:SPI 1.4.0, Device:STM32Cube HAL:UART 1.4.0, Device:Startup 2.4.0
